# Keil uVision project GD25Q_STM32H7.uvprojx, settings and files
target Cortex-M (6140000::V6.14::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: GD25Q_STM32H7
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\GD25Q
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group :STM32CubeMX:Common Sources
    ./STM32CubeMX/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./STM32CubeMX/STCubeGenerated/Inc/: stm32h7xx_it.h
  group System File
    ./RTE/Device/STM32H750XBHx/: system_stm32h7xx.c
  group QSPI Driver
    ./GD25Q/: quadspi.c quadspi.h
software components: CMSIS:CORE 5.4.0, Device:STM32Cube HAL:Common 1.11.0, Device:STM32Cube HAL:Cortex 1.11.0, Device:STM32Cube HAL:GPIO 1.11.0, Device:STM32Cube HAL:MDMA 1.11.0, Device:STM32Cube HAL:PWR 1.11.0, Device:STM32Cube HAL:QSPI 1.11.0, Device:STM32Cube HAL:RCC 1.11.0, Device:Startup 1.11.0
