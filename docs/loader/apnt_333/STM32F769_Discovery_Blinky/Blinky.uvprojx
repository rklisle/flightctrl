# Keil uVision project Blinky.uvprojx, settings and files
target Ext Data (6140000::V6.14::ARMCLANG)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\MX25L51245G
  memory RVCT1: ROM 0x90000000 size 0x4000000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT6: RAM 0x20020000 size 0x1000
  memory RVCT9: RAM 0x20021000 size 0x5f000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source Files
    ./: Blinky.c Data.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F769NIHx/STCubeGenerated/Src/: main.c stm32f7xx_it.c
    ./RTE/Device/STM32F769NIHx/STCubeGenerated/Inc/: stm32f7xx_it.h
  group QUADSPI Memory
    ./MX25L51245G/: quadspi.c
target Ext Data + Code (6140000::V6.14::ARMCLANG)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: as above
  output: Blinky
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\MX25L51245G
  memory RVCT1: ROM 0x90000000 size 0x400000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT6: RAM 0x20020000 size 0x1000
  memory RVCT9: RAM 0x20021000 size 0x5f000
  memory RVCT10: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.2.1, CMSIS:RTOS2:Keil RTX5 5.5.1, Compiler:Event Recorder 1.4.0, Board Support:Buttons 1.1.0, Board Support:LED 1.1.0, Device:STM32Cube HAL:Common 1.2.8, Device:STM32Cube HAL:Cortex 1.2.8, Device:STM32Cube HAL:DMA 1.2.8, Device:STM32Cube HAL:GPIO 1.2.8, Device:STM32Cube HAL:PWR 1.2.8, Device:STM32Cube HAL:QSPI 1.2.8, Device:STM32Cube HAL:RCC 1.2.8, Device:Startup 1.2.5
