# Keil uVision project STM32F769I_Discovery_QPSI_MX25L51245G.uvprojx, settings and files
target STM32F769I_Disco_MX25L51245G (6140000::V6.14::ARMCLANG)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32F769I_Disco_MX25L51245G
  AfterMake: cmd.exe /C copy ".\Objects\%L" "@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\MX25L51245G
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F769NIHx/STCubeGenerated/Src/: main.c stm32f7xx_it.c
    ./RTE/Device/STM32F769NIHx/STCubeGenerated/Inc/: stm32f7xx_it.h
  group QUADSPI Memory
    ./MX25L51245G/: quadspi.c
  group System
    ./RTE/Device/STM32F769NIHx/STCubeGenerated/Src/: system_stm32f7xx.c
software components: CMSIS:CORE 5.4.0, Device:STM32Cube HAL:Common 1.2.8, Device:STM32Cube HAL:Cortex 1.2.8, Device:STM32Cube HAL:DMA 1.2.8, Device:STM32Cube HAL:GPIO 1.2.8, Device:STM32Cube HAL:PWR 1.2.8, Device:STM32Cube HAL:QSPI 1.2.8, Device:STM32Cube HAL:RCC 1.2.8, Device:Startup 1.2.5
