# Keil uVision project Blinky.uvprojx, settings and files
target Ext Data (6140000::V6.14::ARMCLANG)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\MX25R6435F
  asm define: RAM_TARGET
  memory RVCT1: ROM 0x90000000 size 0x4000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x2003f000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x3f000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: Blinky.c Data.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L496AGIx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L496AGIx/STCubeGenerated/Inc/: stm32l4xx_it.h
  group QUADSPI Memory
    ./MX25R6435F/: quadspi.c
target Ext Data + Code (6140000::V6.14::ARMCLANG)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: as above
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\MX25R6435F
  asm define: RAM_TARGET
  memory RVCT1: ROM 0x90000000 size 0x4000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x2003f000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x3f000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.2.1, CMSIS:RTOS2:Keil RTX5 5.5.1, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:I/O 1.1.0, Board Support:Joystick 1.1.0, Board Support:LED 1.1.0, Device:STM32Cube HAL:Common 1.11.1, Device:STM32Cube HAL:Cortex 1.11.1, Device:STM32Cube HAL:DMA 1.11.1, Device:STM32Cube HAL:GPIO 1.11.1, Device:STM32Cube HAL:I2C 1.11.1, Device:STM32Cube HAL:PWR 1.11.1, Device:STM32Cube HAL:QSPI 1.11.1, Device:STM32Cube HAL:RCC 1.11.1, Device:STM32Cube HAL:SRAM 1.11.1, Device:Startup 1.3.1
