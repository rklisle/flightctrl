# Keil uVision project STM32L469_Discovery_QSPIS_MX25R6435F.uvprojx, settings and files
target Cortex-M (6140000::V6.14::ARMCLANG)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM32L496G_Disco_MX25R6435F
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\MX25R6435F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L496AGIx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L496AGIx/STCubeGenerated/Inc/: stm32l4xx_it.h
  group QUADSPI Memory
    ./MX25R6435F/: quadspi.c
  group System File
    ./RTE/Device/STM32L496AGIx/: system_stm32l4xx.c
software components: CMSIS:CORE 5.2.1, Device:STM32Cube HAL:Common 1.11.1, Device:STM32Cube HAL:Cortex 1.11.1, Device:STM32Cube HAL:DMA 1.11.1, Device:STM32Cube HAL:GPIO 1.11.1, Device:STM32Cube HAL:PWR 1.11.1, Device:STM32Cube HAL:QSPI 1.11.1, Device:STM32Cube HAL:RCC 1.11.1, Device:Startup 1.3.1
