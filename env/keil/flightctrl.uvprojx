# Keil uVision project flightctrl.uvprojx, settings and files
target boot (ARM-GNU)
  device: STM32H753XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: boot
  AfterMake: c:/program files (x86)/arm gnu toolchain arm-none-eabi/12.3 rel1/bin/arm-none-eabi-size  --format=berkeley ./Output/boot/boot.elf
  group app
    ../../src/app/: main.c tx_initialize_low_level.S nor_flash.c uart_agent.c rm3100.c icm20689.c pressure_sensor.c control_algorithm.c data_collector.c adis16507.c icm42688.c navi_algorithm.c drv_test.c nor_flash.h can_demo.c app_can.c app_can.h nav_1ms.c
  group boot
    ../../src/boot/: boot.c boot_nor_flash.c
  group bsp
    ../../src/bsp/: syscalls.c
    ../../src/bsp/fcs_cpu/: fcs_bsp_main.c
    ../../src/bsp/navi_cpu/: navi_bsp_main.c
  group fcs_cpu
    ../../src/bsp/fcs_cpu/: stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c startup_stm32h753xx.s system_stm32h753.c
  group navi_cpu
    ../../src/bsp/navi_cpu/: system_stm32h7xx.c stm32h7xx_it.c stm32h7xx_hal_timebase_tim.c stm32h7xx_hal_msp.c startup_stm32h723vghx.s
  group threadx
    ../../src/libs/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
    ../../src/libs/threadx/ports/cortex_m7/gnu/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_interrupt_disable.S tx_thread_interrupt_restore.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
  group stm32_hal
    ../../src/bsp/stm32h7xx_hal/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_fmac.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nor.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pssi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal.c stm32h7xx_hal_sd.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_fmc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_adc.c
    ../../src/bsp/stm32h7xx_hal/STM32H7xx_HAL_Driver/Inc/: stm32h7xx_hal_adc_ex.h
  group cmsis_driver
    ../../src/bsp/cmsis_drivers/: EMAC_STM32H7xx.c FDCAN_STM32H7xx.c I2C_STM32H7xx.c SmartCard_STM32H7xx.c SPI_STM32H7xx.c UART_STM32H7xx.c USART_STM32H7xx.c
  group ringbuffer
    ../../src/libs/ringbuffer/: ringbuffer.c
  group AppMain
    ../../src/app/AppSource/: FlightSupport.c FlightSupport.h StateMachine.c StateMachine.h stmToZynq.c stmToZynq.h
  group AppSupport
    ../../src/app/: sd_flash.c sd_flash.h
    ../../src/app/AppSource/support/: common.c common.h os_basic.c os_basic.h os_bufferLoop.c os_bufferLoop.h os_bufferQueue.c os_bufferQueue.h os_error.c os_error.h os_framework.h os_types.h support.c support.h
    ../../src/app/AppSource/drive/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c pwm_ctrl.c pwm_ctrl.h
  group AppCore
    ../../src/app/AppSource/core/: BusInteract.h BusInteract.c DataPool.c DataPool.h Telecontrol.c Telecontrol.h Telemetry.c Telemetry.h TelemetryDef.h
  group AppInterface
    ../../src/app/AppSource/Interface/: interface_can.c interface_can.h interface_flash.c interface_flash.h interface_gpio.c interface_gpio.h interface_power.h interface_power.c interface_pwm.c interface_pwm.h interface_uart.c interface_uart.h interface_eth.h interface_eth.c
  group AppController
    ../../src/app/AppSource/controller/: controller.c controller.h
  group AppPayload
    ../../src/app/AppSource/payload/: MsnTime.c MsnTime.h payLoadController.c payLoadController.h scout.c scout.h fuse.c fuse.h
  group AppModules
    ../../src/app/AppSource/modules/: modFlash.c modFlash.h modHil.c modHil.h modNav.c modNav.h modOnceBattery.c modOnceBattery.h modPwrSeqCtl.c modPwrSeqCtl.h modSD.c modSD.h modSrvCtl.c modSrvCtl.h modMEMS.c modMEMS.h modEngine.c modEngine.h
  group AppFlight
    ../../src/app/AppSource/flight/: Control.c Control.h Ctrl_Law_Typedef.h FCC_Lib.c FCC_Lib.h os_flight_io.c os_flight_io.h PGuide.c PGuide.h RoutePoint.h WP.c WP.h
  group AppMission
    ../../src/app/AppSource/mission/: mission.c mission.h
  group NavMain
    ../../src/app/NavSource/: stmToZynq.c stmToZynq.h navSupport.c navSupport.h StateMachine.c StateMachine.h
  group NavCore
    ../../src/app/NavSource/core/: BusInteract.c BusInteract.h DataPool.c DataPool.h Telecontrol.c Telecontrol.h
  group NavInterface
    ../../src/app/NavSource/interface/: interface_uart.c interface_uart.h interface_flash.c interface_flash.h
  group NavController
    ../../src/app/NavSource/controller/: controller.c controller.h
  group NavNavigation
    ../../src/app/NavSource/nav/: nav2.c nav2.h
  group NavModules
    ../../src/app/NavSource/modules/: modFlash.c modFlash.h modFlyCtrl.c modFlyCtrl.h modGps.c modGps.h modImu.c modImu.h
  group NavSupport
    ../../src/app/NavSource/support/: common.c common.h os_basic.c os_basic.h os_bufferLoop.c os_bufferLoop.h os_bufferQueue.c os_bufferQueue.h os_error.c os_error.h os_framework.h os_types.h support.c support.h
target navi (ARM-GNU)
  device: STM32H723VGHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00050000) IROM(0x08000000,0x00100000) XRAM(0x30000000,0x00008000) XRAM2(0x38000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: navi
  AfterMake: c:/program files (x86)/arm gnu toolchain arm-none-eabi/12.3 rel1/bin/arm-none-eabi-size  --format=berkeley ./Output/navi/navi.elf
target fcs (ARM-GNU)
  device: STM32H753XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: as above
  output: fcs +hex
  AfterMake: c:/program files (x86)/arm gnu toolchain arm-none-eabi/12.3 rel1/bin/arm-none-eabi-size  --format=berkeley ./Output/fcs/fcs.elf
  AfterMake: c:/program files (x86)/arm gnu toolchain arm-none-eabi/12.3 rel1/bin/arm-none-eabi-objcopy -O binary .\Output\fcs\fcs.elf .\Output\fcs\fcs.bin
